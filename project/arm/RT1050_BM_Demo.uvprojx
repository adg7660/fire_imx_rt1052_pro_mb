# Keil uVision project RT1050_BM_Demo.uvprojx, settings and files
target RT1050_BM_Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.4
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: RT1050_BM_Demo
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1052DVL6B, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE =1, XIP_BOOT_HEADER_DCD_ENABLE =1, USE_RAM_VECTOR_TABLE
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..\..\app;..\..\board;..\..\board\xip;..\..\libraries\CMSIS\Driver\Include;..\..\libraries\CMSIS\Include;..\..\libraries;..\..\libraries\cmsis_drivers;..\..\libraries\drivers;..\..\libraries\utilities;..\..\libraries\utilities\io;..\..\libraries\utilities\io\swo;..\..\libraries\utilities\log;..\..\libraries\utilities\str
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\config\MIMXRT1052xxxxx_flexspi_nor_sdram.scf
  link misc: --keep=*(.boot_hdr.conf)
--keep=*(.boot_hdr.ivt)
  group app
    ../../app/: main.c
  group board
    ../../board/: board.c clock_config.c pin_mux.c
  group cmsis
    ../../libraries/: system_MIMXRT1052.c
    ./config/: startup_MIMXRT1052.s
  group libraries
    ../../libraries/drivers/: fsl_clock.c fsl_common.c fsl_gpio.c fsl_lpuart.c
  group utilitys
    ../../libraries/utilities/: fsl_assert.c fsl_debug_console.c fsl_notifier.c fsl_sbrk.c fsl_shell.c
    ../../libraries/utilities/str/: fsl_str.c
    ../../libraries/utilities/log/: fsl_log.c
    ../../libraries/utilities/io/: fsl_io.c
  group xip
    ../../board/xip/: fire_imxrt1052_sdram_ini_dcd.c fire_imxrt1052_spiflash_config.c fsl_flexspi_nor_boot.c
